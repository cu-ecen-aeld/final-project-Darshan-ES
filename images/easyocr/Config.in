## images/easyocr/Config.in
```kconfig
config BR2_PACKAGE_EASYOCR
    bool "easyocr"
    help
      Python-based Optical Character Recognition library.
```
